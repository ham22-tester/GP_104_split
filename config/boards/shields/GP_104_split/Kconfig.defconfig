## config/boards/shields/GP_104_split/Kconfig.defconfig
```kconfig
if SHIELD_GP_104_SPLIT

config ZMK_KEYBOARD_NAME
    default "GP_104_split"

endif
```
